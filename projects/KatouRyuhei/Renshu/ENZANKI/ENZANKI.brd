# Repository KNCTRobo/Eagle (continued)

## EAGLE design projects/hukuzawa/MotorDriver2016/MotorDriver2016.brd (continued)

Board: 2 copper layers, 116.8 x 99.1 mm, 54 parts (13 on the bottom side), 48 nets.

## EAGLE design projects/hukuzawa/MDTester/MDTester.brd

Parts:
BATT: 3X1A; 37203-62A3-003
C1, C2: 47uF; E2-5
C3: C0.1UF
H1, H2, H3, H4: HOLE3.3M3BOLT; HOLE3.3
I2C: 4X2; 37208-62A3-004
LEDA1, LEDA2, LEDA3, LEDA4: LED5MM
LEDB1, LEDB2, LEDB3, LEDB4: LED5MM
LEDC1, LEDC2, LEDC3, LEDC4: LED5MM
LEDD1, LEDD2, LEDD3, LEDD4: LED5MM
LEDF1, LEDF2, LEDF3: LED5MM
LEDOPR: LED5MM
NJM1: 3TARMINALREGULATOR7800; TO-220
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16: 1k; R3216W
RX: 3X1A; 37203-62A3-003
S1: SLIDESW
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8: TACTSW; TACT
TR1, TR2, TR3, TR4: 2SC1815; TO92-
TX: 3X1A; 37203-62A3-003
U$1: PIC16F886; DIL28

Connections:
+5V: C2.+, C3.1, LEDF1.A, LEDF2.A, LEDF3.A, LEDOPR.A, NJM1.OUT, R9.1, R10.1, R11.1, R12.1, R13.1, R14.1, R15.1, R16.1, TR1.C, TR2.C, TR3.C, TR4.C, U$1.20 (VDD)
BATTLINE: BATT.1-2, S1.3
GND: BATT.1-1, BATT.1-3, C1.-, C2.-, C3.2, I2C.1-1, I2C.2-1, NJM1.GND, R1.2, R2.2, R3.2, R4.2, R5.1, R6.1, R7.1, R8.1, RX.1-1, S1.1, SW1.4 (P1), SW2.4 (P1), SW3.4 (P1), SW4.4 (P1), SW5.4 (P1), SW6.4 (P1), SW7.4 (P1), SW8.4 (P1), TX.1-1, U$1.8 (VSS1), U$1.19 (VSS2)
LEDF1: LEDF1.K (C), R1.1, U$1.11 (RC0/T1OSO/T1CKI)
LEDF2: LEDF2.K (C), R2.1, U$1.12 (RC1/T1OSI/CCP2)
LEDF3: LEDF3.K (C), R3.1, U$1.13 (RC2/P1A/CCP1)
LEDM1: LEDA1.K (C), LEDB1.K (C), LEDC1.K (C), LEDD1.K (C), R8.2, U$1.6 (RA4/TOCKI/C1OUT)
LEDM2: LEDA2.K (C), LEDB2.K (C), LEDC2.K (C), LEDD2.K (C), R7.2, U$1.7 (RA5/AN4/!SS!/C2OUT)
LEDM3: LEDA3.K (C), LEDB3.K (C), LEDC3.K (C), LEDD3.K (C), R6.2, U$1.9 (RA7/OSC1/CLKIN)
LEDM4: LEDA4.K (C), LEDB4.K (C), LEDC4.K (C), LEDD4.K (C), R5.2, U$1.10 (RA6/OSC2/CLKOUT)
LEDMA: TR1.B, U$1.5 (RA3/AN3/VREF+/C1IN+)
LEDMB: TR2.B, U$1.4 (RA2/AN2/VREF-/CVREF/C2IN+)
LEDMC: TR3.B, U$1.3 (RA1/AN1/C12IN1-)
LEDMD: TR4.B, U$1.2 (RA0/AN0/ULPWU/C12IN0-)
LEDOPR: LEDOPR.K (C), R4.1, U$1.16 (RC5/SDO)
MCLR: U$1.1 (!MCLR)
unnamed: LEDA1.A, LEDA2.A, LEDA3.A, LEDA4.A, TR1.E
unnamed: LEDB1.A, LEDB2.A, LEDB3.A, LEDB4.A, TR2.E
unnamed: LEDC1.A, LEDC2.A, LEDC3.A, LEDC4.A, TR3.E
unnamed: LEDD1.A, LEDD2.A, LEDD3.A, LEDD4.A, TR4.E
RX: RX.1-3, U$1.18 (RC7/RX/DT)
SCK: I2C.1-3, I2C.2-3, U$1.14 (RC3/SCK/SCL)
SDI: I2C.1-4, I2C.2-4, U$1.15 (RC4/SDI/SDA)
SW1: R9.2, SW1.1 (S), U$1.21 (RB0/AN12/INT)
SW2: R10.2, SW2.1 (S), U$1.22 (RB1/AN10/P1C/C12IN3-)
SW3: R11.2, SW3.1 (S), U$1.23 (RB2/AN8/P1B)
SW4: R12.2, SW4.1 (S), U$1.24 (RB3/AN9/PGM/C12IN2-)
SW5: R13.2, SW5.1 (S), U$1.25 (RB4/AN11/P1D)
SW6: R14.2, SW6.1 (S), U$1.26 (RB5/AN13/!T1G)
SW7: R15.2, SW7.1 (S), U$1.27 (RB6/ICSPCLK)
SW8: R16.2, SW8.1 (S), U$1.28 (RB7/ICSPDAT)
TX: TX.1-3, U$1.17 (RC6/TX/CK)
V+: C1.+, I2C.1-2, I2C.2-2, NJM1.IN, RX.1-2, S1.2, TX.1-2

Notes on the sheet:
リセット回路
コントローラ
LEDマトリクス
LED表示部
スイッチ
I2C

Board: 2 copper layers, 106.7 x 76.2 mm, 62 parts (16 on the bottom side), 32 nets.

## EAGLE design projects/hukuzawa/Debuger/debuger.brd

Parts:
C1, C2: CPOL-EU2-5MM; E2-5
C3: C0.1UF
H1, H2, H3, H4: HOLE3.3M3BOLT; HOLE3.3
IC1: PIC16F886; DIL28
J1: 3X1A; 37203-62A3-003
LED1, LED2: LED5MM
NJM1: NJM7805
R1, R2, R3, R4, R5, R6: R-EU_R3216W; R3216W
S1: SLIDESW
SW1-1, SW1-2, SW1-3, SW1-4, SW2-1, SW2-2, SW2-3, SW2-4, SW3-1, SW3-2, SW3-3, SW3-4, SW4-1, SW4-2, SW4-3, SW4-4: TACTSW; TACT
TR1, TR2, TR3, TR4: 2SC1815; TO92-

Connections:
+5V: C2.+, C3.1, IC1.20 (VDD), NJM1.OUT, S1.1, TR1.C, TR2.C, TR3.C, TR4.C
BR1: IC1.25 (RB4/AN11/P1D), R6.1, SW1-1.3, SW2-1.3, SW3-1.3, SW4-1.3
BR2: IC1.26 (RB5/AN13/!T1G), R5.1, SW1-2.3, SW2-2.3, SW3-2.3, SW4-2.3
BR3: IC1.27 (RB6/ICSPCLK), R4.1, SW1-3.3, SW2-3.3, SW3-3.3, SW4-3.3
BR4: IC1.28 (RB7/ICSPDAT), R3.1, SW1-4.3, SW2-4.3, SW3-4.3, SW4-4.3
BS1: IC1.21 (RB0/AN12/INT), TR1.B
BS2: IC1.22 (RB1/AN10/P1C/C12IN3-), TR2.B
BS3: IC1.23 (RB2/AN8/P1B), TR3.B
BS4: IC1.24 (RB3/AN9/PGM/C12IN2-), TR4.B
GND: C1.-, C2.-, C3.2, IC1.8 (VSS1), IC1.19 (VSS2), J1.1-3, NJM1.GND, R1.2, R2.2, R3.2, R4.2, R5.2, R6.2, S1.3
unnamed: C1.+, J1.1-1, NJM1.IN
unnamed: IC1.17 (RC6/TX/CK), J1.1-2
unnamed: LED1.K (C), R1.1
unnamed: LED2.K (C), R2.1
OPLED: IC1.11 (RC0/T1OSO/T1CKI), LED1.A
SGLED: IC1.12 (RC1/T1OSI/CCP2), LED2.A
SGSW: IC1.13 (RC2/P1A/CCP1), S1.2
SS1: SW1-1.2 (S1), SW1-2.2 (S1), SW1-3.2 (S1), SW1-4.2 (S1), TR1.E
SS2: SW2-1.1 (S), SW2-2.1 (S), SW2-3.1 (S), SW2-4.1 (S), TR2.E
SS3: SW3-1.2 (S1), SW3-2.2 (S1), SW3-3.2 (S1), SW3-4.2 (S1), TR3.E
SS4: SW4-1.2 (S1), SW4-2.2 (S1), SW4-3.2 (S1), SW4-4.2 (S1), TR4.E

Notes on the sheet:
コントローラ

Board: 2 copper layers, 100.0 x 72.0 mm, 39 parts (6 on the bottom side), 21 nets.

## Commit log

2017-05-12 最初のコミット
2017-05-12 robo-PC2内データの統合
2017-05-12 フォルダの整理、バックアップファイルの削除
2017-05-12 プロジェクト名の変更
2017-05-12 ERA8Aの追加
2017-05-12 デバイスとシンボル
2017-05-13 未使用プロジェクトの削除、デザインルールの追加
2017-05-15 パッケージ途中
2017-05-15 フォルダの整理
    一部上書きされているファイルが存在するため、必要があれば過去のコミットを参照してください
2017-05-15 バックアップファイルの削除
2017-05-15 プロジェクトの作成
2017-05-16 BUK116-50L完成
2017-05-16 BUK116-50L 修正
2017-05-16 BUK116-50Lのライブラリへの追加
    BUK116-50Lをライブラリフォルダに追加、元プロジェクトの削除
2017-05-16 FH105-1xXXSGシリーズのライブラリへの追加
    ピンソケットFH105-1xXXSGをライブラリへ追加、元ファイルを削除
2017-05-17 回路図データ追加
2017-05-17 FH-105のデバイスがパッケージとリンクされていない問題の修正
2017-05-17 FH105シリーズ微修正
2017-05-17 回路図作業途中
2017-05-20 3M 372xxシリーズの微修正
2017-05-20 回路図製作経過
2017-05-25 回路図製作経過
    制御部配線が7割程度完了
2017-06-08 ドライバスペーサ部と駆動部のデータ作成
2017-06-08 BUK116-50L修正
    BUK116-50Lのピンが表示されない問題を修正
2017-06-08 ドライバ駆動部回路図製作経過
2017-06-09 モータードライバ駆動部回路図製作途中
    フォトカプラ追加、配線一部完了
2017-06-10 モータードライバ駆動部製作途中
2017-06-10 使用ライブラリ追加の反映
2017-06-12 モータードライバ駆動部回路図完成
2017-06-13 モータードライバ制御部回路図製作途中
2017-06-14 モータードライバ制御部回路図完成
2017-06-14 モータードライバボード図2枚一時完成
2017-06-15 モータードライバ駆動部ボード図一時完成
2017-06-15 モータードライバ駆動部修正
2017-06-15 モータードライバ駆動部リレー修正
2017-06-16 モータドライバ制御部 ボード図一時完成
2017-06-16 モータードライバ全ボード図完成
2017-06-19 モータードライバ修正
    モータードライバのジャンパ線部のドリル径を修正
    それに伴って一部の配置の修正
2017-06-20 モータードライバドリル用データ作成
2017-06-22 モータードライバデータ修正
    ドリル径の修正、それに伴う配置の若干の変更
    ダイオードのライブラリの修正
2017-06-23 モータードライバ修正
    穴径を1.0～1.2mmの範囲に収まるよう修正
    Dimensionラインの太さを0に修正
2017-06-24 モータードライバ修正
    Base,Space: 基板の無駄であるため削除
    Drive: 基板固定用の穴を追加
2017-06-26 モータードライバ全ボード図修正
    配置の基準単位をmilに変更して再配置・再配線
2017-06-26 モータードライバ修正
    すべての配線の名前を変更
2017-06-28 モータードライバ修正
    使用ヒューズホルダー変更
2017-07-03 プロジェクト作成
    マザーボードのプロジェクトを作成、PICのライブラリを作成
2017-07-05 マザーボード完成
2017-07-05 .gitignore追加
2017-07-07 デザインルール更新
2017-07-08 マザーボード修正
    一部文字の見えにくい部分を修正
    PICのライブラリの重大な問題を修正
    回路図・ボード図をpng,pdfにエクスポート
2017-07-08 マザーボード修正
    3.3mm穴がショートしないよう修正
2017-07-08 マザーボード使用ライブラリ更新
2017-07-08 練習用基板
2017-07-15 デバッガ作成(初版完成)
2017-07-17 デバッガ基板微修正
    配線を修正、ジャンパを1個削減
2017-07-17 練習用基板 使用ライブラリ更新
2017-09-04 ライブラリ整理
2017-09-04 モータードライバ回路pngファイルエクスポート
2017-09-04 マザーボード回路修正
    配置の見直し・再配線
    使用ライブラリの更新
2017-09-05 モータードライバテスト用回路作成
2017-09-05 マザーボード回路ver1.20
    ポート部分仕様変更
    再配置・再配線
    回路基板サイズの縮小
2017-09-05 モータードライバテスト回路 プロジェクトファイル更新
2017-09-06 モータードライバ
    既存のモータードライバを再配線したものを作成
2017-09-06 旧モータードライバ修正
    ハッチングデータ修正
2017-09-06 CAMデータ追加
2017-09-06 gitignoreファイル修正
    CAMによる生成データ対応
2017-09-08 マザーボード回路 v1.21
    PICから外部に流す電源を制御するよう仕様変更
2017-09-29 旧モータードライバ更新
    使用抵抗の値を変更
    イメージファイルにエクスポート
2017-12-01 EAGLEのテスト
2017-12-02 プロジェクト作成
    配線導通チェッカのプロジェクトを作成
2017-12-02 配線導通チェッカー
2017-12-02 配線導通チェッカ使用ライブラリ更新
2017-12-04 プロジェクトファイル作成
    8LED表示器
2017-12-04 回路図作成
2017-12-05 回路図の修正
    schemeticファイルの余計な配線を削除
2017-12-05 ボード図作成
2017-12-06 回路図の修正
    DRCのエラーの修正
2017-12-06 プロジェクトファイル変更の反映
2017-12-06 ボード図の作成
    LED判定板のボード図作成
2017-12-07 ボード図の修正
    ライン間等の圧縮
2017-12-09 ライブラリの整理
    使用ライブラリを一か所に集約
2017-12-09 マザーボード修正
    規格化されたポートを分離、ライブラリを新規に作成
2017-12-09 マザーボード回路修正
    マザーボード回路ポートライブラリのデータを画像としてエクスポート
2017-12-11 Eagleプロジェクトファイル変更の適用
2017-12-11 演算機の回路図ファイル作成
2017-12-11 回路図作成
    演算機の回路図を作成
2017-12-12 回路図の作成
    作成途中
2017-12-12 回路図とボード図の画像エクスポート
2017-12-12 Eagleプロジェクトファイル変更の反映
2017-12-12 エクスポート画像を正しい場所に再配置
2017-12-13 演算機の回路図の作成
    製作途中
2017-12-14 回路図の作成
2017-12-14 回路図とボード図の作成
    作成途中
2018-04-19 10進数2桁カウンタ
2018-04-19 10進数2桁カウンタスケマティックファイル
2018-04-20 2桁10進数カウンタ
2018-04-23 10進数2桁カウンタ作成途中
2018-04-24 10進数2桁カウンタ製作途中
