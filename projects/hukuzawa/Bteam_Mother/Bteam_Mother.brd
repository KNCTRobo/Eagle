# Repository KNCTRobo/Eagle

## EAGLE design projects/hukuzawa/Bteam_Mother/Bteam_Mother.brd

Parts:
9VIN: 5051-2; 2PL
C1, C2: 35V 47uF; E2-5
C3: C0.1UF
J2: 5051-10; 10PL
LED1: Red; LED5MM
LED2: LED5MM
NJM1: NJM7805
PIC16F1: PIC16F886; DIL28-3
R1, R2: 1k; 0207/10
RCV: 5051-3; 3PL
S1: SLIDESW
U$1, U$2, U$3, U$4: 1MMDRILL; 1MDRILL
XMIT: 5051-3; 3PL

Connections:
unnamed: C2.+, C3.1, J2.1, NJM1.OUT, PIC16F1.20 (VDD(VCC))
unnamed: C1.+, NJM1.IN, RCV.2, S1.2, XMIT.2
unnamed: J2.3, PIC16F1.21 (RB0/AN12/INT)
unnamed: LED1.K (C), R2.2
unnamed: LED2.A, PIC16F1.16 (RC5)
unnamed: PIC16F1.17 (RC6/TX), XMIT.3
unnamed: 9VIN.2, C1.-, C2.-, C3.2, J2.2, NJM1.GND, PIC16F1.8 (VSS(GND)), R1.2, R2.1, RCV.1, XMIT.1
unnamed: J2.4, PIC16F1.22 (RB1/AN10)
unnamed: J2.5, PIC16F1.23 (RB2/AN8)
unnamed: J2.8, PIC16F1.26 (RB5/AN13/!T1G)
unnamed: PIC16F1.18 (RC7/RX), RCV.3
unnamed: J2.7, PIC16F1.25 (RB4/AN11)
unnamed: LED2.K (C), R1.1
unnamed: J2.6, PIC16F1.24 (RB3/AN9/PGM)
unnamed: J2.9, PIC16F1.27 (RB6/ICSPCLK)
unnamed: J2.10, PIC16F1.28 (RB7/ICSPDAT)
unnamed: 9VIN.1, S1.1
RED: LED1.A, PIC16F1.2 (RA0/AN0)
_VSS(GND): PIC16F1.19 (_VSS(GND))

Board: 2 copper layers, 73.0 x 55.0 mm, 18 parts (0 on the bottom side), 18 nets.

## EAGLE design projects/hukuzawa/Motordriver/MD2017_Ctrl.brd

Parts:
C1, C2: 47uF; E2-5
C3: C0.1UF
D1, D2, D3, D4: Z-DIODE; DO201-15
IC1: PIC16F648; DIL18
J1: 3X2A; 37206-62A3-003
LED1: LED5MM
NJM1: NJM7805
POWERNPORT: 8PIN; FH105-1X8SG
POWERPPORT: 8PIN; FH105-1X8SG
Q1: CERALOCK
R1: 1k; R3216W
SIGNALPORT: 8PIN; FH105-1X8SG
U$2: 2P
U$3: F-115

Connections:
9VIN: C1.+, J1.1-1, J1.2-1, NJM1.IN
AD/B: IC1.13 (RB7), SIGNALPORT.4
ADIR: IC1.12 (RB6), SIGNALPORT.5
APWM: IC1.11 (RB5), SIGNALPORT.3
BATTA: U$2.P2, U$3.2; also elsewhere on the board
BATTB: D3.A, D4.C, U$2.P1
BD/B: IC1.18 (RA1), SIGNALPORT.7
BDIR: IC1.1 (RA2), SIGNALPORT.8
BPWM: IC1.17 (RA0), SIGNALPORT.6
CLK1: IC1.15 (OSC1), Q1.P$3
CLK2: IC1.16 (OSC2), Q1.P$1
GND: C1.-, C2.-, C3.2, IC1.5 (VSS), J1.1-3, J1.2-3, NJM1.GND, Q1.P$2, SIGNALPORT.2
GND2: D1.A, D4.A, POWERNPORT.1, POWERNPORT.2, POWERNPORT.3, POWERNPORT.4, POWERNPORT.5, POWERNPORT.6, POWERNPORT.7, POWERNPORT.8
unnamed 13: D1.C, D2.A, U$3.1; also elsewhere on the board
unnamed: IC1.3 (T0CKI/RA4), R1.1
NLED1: LED1.K (C), R1.2
SIGNAL: IC1.7 (RB1), J1.1-2, J1.2-2
VCC12V: D2.C, D3.C, POWERPPORT.1, POWERPPORT.2, POWERPPORT.3, POWERPPORT.4, POWERPPORT.5, POWERPPORT.6, POWERPPORT.7, POWERPPORT.8
VDD5V: C2.+, C3.1, IC1.14 (VDD), LED1.A, NJM1.OUT, SIGNALPORT.1

Board: 2 copper layers, 70.0 x 70.0 mm, 18 parts (1 on the bottom side), 19 nets.

Other parts of the board:
FUSE: MF-550C; MF550C

Their connections:
BATTA: FUSE.PB; also elsewhere on the board
unnamed 13: FUSE.PA; also elsewhere on the board

## EAGLE design projects/hukuzawa/Motordriver/MD2017_Drive.brd

Parts:
D1, D2: DIODE7.5
FET1: BUK116-50L
LED1: LED5MM
POWERNPORT: 8PIN; FH105-1X8SG
POWERPPORT: 8PIN; FH105-1X8SG
R1, R9, R10: R-EU_R3216W; R3216W
R2, R3, R4, R5, R6, R7, R8: 300; R3216W
SIGNALPORT: 8PIN; FH105-1X8SG
U$5, U$6: RELAY(L); G2R2
U$7, U$8: TLP521-4; 16PIN
U$9: 2P

Connections:
AD/B: R4.2, SIGNALPORT.4
ADIR: R5.2, SIGNALPORT.5
APWM: R3.2, SIGNALPORT.3
BD/B: R7.2, SIGNALPORT.7
BDIR: R8.2, SIGNALPORT.8
BPWM: R6.2, SIGNALPORT.6
BRAKES: U$6.2 (S), U$6.7 (S)
D/B: R10.2, U$7.11 (EMIT), U$8.11 (EMIT)
DIR: R9.2, U$7.9 (EMIT), U$8.9 (EMIT)
DIRN: U$5.6, U$6.5 (O)
DIRP: U$5.3, U$6.4 (O)
GND-C: SIGNALPORT.2, U$7.2 (C), U$7.4 (C), U$7.6 (C), U$7.8 (C), U$8.2 (C), U$8.4 (C), U$8.6 (C), U$8.8 (C)
GND-D: D1.PA (A), D2.PA (A), LED1.K (C), POWERNPORT.1, POWERNPORT.2, POWERNPORT.3, POWERNPORT.4, POWERNPORT.5, POWERNPORT.6, POWERNPORT.7, POWERNPORT.8, U$5.4 (O), U$5.7 (S), U$5.8 (2), U$6.8 (2)
unnamed: FET1.2 (F), R1.2
unnamed: LED1.A, R1.1
NCSUPP1: R2.1, U$7.1 (A), U$8.1 (A)
NDSUPP1: D1.PK (C), R9.1, U$5.1
NDSUPP2: D2.PK (C), R10.1, U$6.1
NSIG1: R3.1, U$7.3 (A)
NSIG2: R4.1, U$7.5 (A)
NSIG3: R5.1, U$7.7 (A)
NSIG4: R6.1, U$8.3 (A)
NSIG5: R7.1, U$8.5 (A)
NSIG6: R8.1, U$8.7 (A)
OUTN: U$6.6, U$9.P1
OUTP: U$6.3, U$9.P2
PROTECTSP.: FET1.4, U$7.15 (EMIT), U$8.15 (EMIT)
PWM: FET1.1 (I), U$7.13 (EMIT), U$8.13 (EMIT)
PWMOUT: FET1.5 (S), U$5.2 (S), U$5.5 (O)
VCC5V: R2.2, SIGNALPORT.1
VCC12V: FET1.3 (D), POWERPPORT.1, POWERPPORT.2, POWERPPORT.3, POWERPPORT.4, POWERPPORT.5, POWERPPORT.6, POWERPPORT.7, POWERPPORT.8, U$7.10 (COL), U$7.12 (COL), U$7.14 (COL), U$7.16 (COL), U$8.10 (COL), U$8.12 (COL), U$8.14 (COL), U$8.16 (COL)

Notes on the sheet:
制御部

Board: 2 copper layers, 70.0 x 70.0 mm, 26 parts (11 on the bottom side), 31 nets.

Other parts of the board:
U$1, U$2, U$3, U$10: HOLE3.3

## EAGLE design projects/kasuga/2015_Amother/2015_Amother.brd

Parts:
C1: C0.1UF
H1, H2, H3, H4: HOLE3.3M3BOLT; HOLE3.3
J1, J2: 3PIN(L); 3PL
J3: 2PIN(L); 2PL
J4, J5, J8: 6PIN(L); 6PL
LEDG: LED3MM
LEDR: LED3MM
NJM1: NJM7805
PIC16F1: PIC16F886; DIL28-3
R1: 10k; 0207/10
R2, R3: 1k; 0207/10
R4, R5, R6: 0; 0207/10
SW1: SWITCH_MININORMAL; SWITCH_MINI
SW2, SW3, SW4, SW5, SW6: TACTSW; TACT
U$1, U$2: C-ELEC; C-6MM

Connections:
unnamed: J3.1, SW1.COM
unnamed: J1.2, J2.2, J4.2, J8.2, NJM1.IN, SW1.1, U$1.+
unnamed: J4.3, R4.1
unnamed: LEDG.A, R3.2
unnamed: PIC16F1.16 (RC5), R1.2, SW6.1 (S)
unnamed: J1.3, R6.1
unnamed: J8.3, PIC16F1.2 (RA0/AN0)
unnamed: J8.4, PIC16F1.3 (RA1/AN1)
unnamed: J8.5, PIC16F1.4 (RA2/AN2/VREF-)
unnamed: J8.6, PIC16F1.5 (RA3/AN3/VREF+)
unnamed: J4.4, R5.1
unnamed: LEDR.A, R2.1
unnamed: C1.2, J1.1, J2.1, J3.2, J4.1, J5.1, J8.1, NJM1.GND, PIC16F1.8 (VSS(GND)), PIC16F1.19 (_VSS(GND)), SW2.1 (S), SW3.1 (S), SW4.1 (S), SW5.1 (S), SW6.3, U$1.-, U$2.-
unnamed: LEDR.K (C), PIC16F1.1 (RE3/!MCLR)
unnamed: PIC16F1.21 (RB0/AN12/INT), SW5.4 (P1)
unnamed: PIC16F1.22 (RB1/AN10), SW4.4 (P1)
unnamed: J4.5, PIC16F1.9 (RA7/OSC1)
unnamed: PIC16F1.24 (RB3/AN9/PGM), SW2.4 (P1)
unnamed: J4.6, PIC16F1.10 (RA6/OSC2)
unnamed: PIC16F1.23 (RB2/AN8), SW3.4 (P1)
unnamed: LEDG.K (C), PIC16F1.15 (RC4/SDA)
unnamed: J5.3, PIC16F1.25 (RB4/AN11)
unnamed: C1.1, J5.2, NJM1.OUT, PIC16F1.20 (VDD(VCC)), R1.1, R2.2, R3.1, U$2.+
unnamed: J5.4, PIC16F1.26 (RB5/AN13/!T1G)
unnamed: PIC16F1.17 (RC6/TX), R6.2
unnamed: J5.5, PIC16F1.27 (RB6/ICSPCLK)
unnamed: J5.6, PIC16F1.28 (RB7/ICSPDAT)
unnamed: PIC16F1.6 (RA4/T0CKI), R4.2
unnamed: PIC16F1.7 (RA5/AN4), R5.2
unnamed: J2.3, PIC16F1.18 (RC7/RX)

Board: 2 copper layers, 68.2 x 72.4 mm, 29 parts (0 on the bottom side), 30 nets.

## EAGLE design projects/kasuga/4port_driver/4port_driver.brd

Parts:
C1, C2: 47uF; C-6MM
C3: C0.1UF
D1, D3, D4, D5: DIODE7.5
H1, H2, H3, H4: HOLE3.3M3BOLT; HOLE3.3
IC1: PIC16F648; DIL18
IC2: TLP521; DIL16
J1: 6PIN(L); 6PL
J2: 3PIN(L); 3PL
LED1: LED; LED5MM
NJM1: NJM7805
Q1: CERALOCK
R1: 1k; 0207/10
R2, R3, R4, R5, R6, R7, R8, R9: 2k; 0207/10
R10, R11, R12, R13: 10k; 0207/10
R14, R15, R16, R17: 300; R0207V
R18: 0; 0207/10
TR1, TR2, TR3, TR4: 2SC2001; TO92BCE
U$1: BP341L_1; BP341L
U$2, U$3: BP341L

Connections:
GND: TR1.E, TR2.E, TR3.E, TR4.E, U$1.P$1 (P1)
unnamed: C1.+, J1.2, J2.2, NJM1.IN
unnamed: C1.-, C2.-, C3.2, IC1.5 (VSS), IC2.2 (C0), IC2.4 (C1), IC2.6 (C2), IC2.8 (C3), J1.1, J2.1, NJM1.GND, Q1.P$2
unnamed: R10.2, R11.2, R12.2, R13.2, R18.1
unnamed: IC1.16 (OSC2), Q1.P$1
unnamed: IC1.15 (OSC1), Q1.P$3
unnamed: IC1.7 (RB1), J2.3
unnamed: IC1.1 (RA2), J1.3, R12.1
unnamed: IC1.2 (RA3), J1.4, R11.1
unnamed: IC1.3 (T0CKI/RA4), J1.5, R10.1
unnamed: IC1.4 (!MCLR), J1.6, R13.1
unnamed: IC1.10 (RB4), R17.2
unnamed: C2.+, C3.1, IC1.14 (VDD), NJM1.OUT, R1.2, R18.2
unnamed: IC1.12 (RB6), R15.2
unnamed: IC2.15 (EMIT0), R5.1
unnamed: LED1.A, R1.1
unnamed: IC1.18 (RA1), LED1.K (C)
unnamed: R8.2, TR4.B
unnamed: IC2.13 (EMIT1), R4.1
unnamed: IC2.11 (EMIT2), R2.1
unnamed: IC2.9 (EMIT3), R3.1
unnamed: R6.2, TR1.B
unnamed: R2.2, R6.1
unnamed: R3.2, R7.1
unnamed: R4.2, R8.1
unnamed: D1.PA (A), TR1.C, U$2.P1
unnamed: D3.PA (A), TR2.C, U$2.P3
unnamed: D4.PA (A), TR3.C, U$3.P1
unnamed: R5.2, R9.1
unnamed: IC2.1 (A0), R14.2
unnamed: R7.2, TR2.B
unnamed: R9.2, TR3.B
unnamed: IC2.3 (A1), R15.1
unnamed: D1.PK (C), D3.PK (C), D4.PK (C), D5.PK (C), IC2.10 (COL3), IC2.12 (COL2), IC2.14 (COL1), IC2.16 (COL0), U$1.P$2 (P2), U$2.P2, U$2.P4, U$3.P2, U$3.P4
unnamed: IC2.5 (A2), R16.2
unnamed: D5.PA (A), TR4.C, U$3.P3
unnamed: IC2.7 (A3), R17.1
unnamed: IC1.13 (RB7), R14.1
unnamed: IC1.11 (RB5), R16.1

Board: 2 copper layers, 94.0 x 82.2 mm, 43 parts (0 on the bottom side), 39 nets.
